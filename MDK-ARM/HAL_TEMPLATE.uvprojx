# Keil uVision project HAL_TEMPLATE.uvprojx, settings and files
target HAL_TEMPLATE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: HAL_TEMPLATE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ..\CMSIS;..\STM32F7xx;..\STM32F7xx_HAL_Driver\Inc;..\USER\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group STARTUP
    ../CMSIS/: startup_stm32f767xx.s
  group CMSIS_CORE
    ../CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h mpu_armv7.h
  group CMSIS_ST
    ../STM32F7xx/: stm32f7xx.h stm32f767xx.h system_stm32f7xx.h
  group STM32F7xx_HAL_Driver
    ../STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c
  group USER
    ../USER/Src/: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c system_stm32f7xx.c
